# IAR project Firmware.ewp, settings and files
configuration Firmware (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\Middlewares\FreeModbus\include; ..\Middlewares\FreeModbus\port; ..\Middlewares\FreeModbus\app; ..\Middlewares\FreeModbus\rtu
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Firmware.hex
  ILINK.IlinkOutputFile: Firmware.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/FreeModbus
    ../Middlewares/FreeModbus/: mb.c
    ../Middlewares/FreeModbus/ascii/: mbascii.c mbascii.h
    ../Middlewares/FreeModbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
    ../Middlewares/FreeModbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Application/port
    ../Middlewares/FreeModbus/port/: port.h portcritical.c portcritical.h portevent.c portserial.c porttimer.c
  group Application/User
    ../Src/: adc.c dma.c gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c usart.c
    ../Middlewares/FreeModbus/app/: user_mb_app.c user_mb_app.h
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
